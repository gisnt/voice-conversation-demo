# Keil uVision project YS-V0.7.uvproj, settings and files
target YS-V0.7口令模式工程 08xe (MCS-51)
  device: STC10F12XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(45000000) MODP2
  output: V07A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c LDChip.c Reg_RW.c
    ./: Syn6288.c
  group Driver
    ../user/: usart.c
